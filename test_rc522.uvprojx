# Keil uVision project test_rc522.uvprojx, settings and files
target rc522 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_rc522
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drivers\inc;.\drivers\src;.\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./: mfrc522.c main.c spi.c flash_data.c
  group header
    ./: main.h spi.h mfrc522.h flash_data.h
  group drivers
    ./drivers/inc/: misc.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_flash.h stm32f10x_usart.h
    ./drivers/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group delay
    ./delay/: delay.c delay.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
